RDEPENDS:${PN}-devtools:remove:numaker-iot-ma35d0 = "trace-enable"
