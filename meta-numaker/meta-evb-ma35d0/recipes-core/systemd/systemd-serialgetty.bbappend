# MA35D0 uses ttyS0 for BMC serial console
SERIAL_CONSOLES = "115200;ttyS0"
