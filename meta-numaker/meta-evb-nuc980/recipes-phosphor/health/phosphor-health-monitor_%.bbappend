FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:nuc980 = " file://bmc_health_config.json"
