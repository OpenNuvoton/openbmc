RDEPENDS:${PN}-devtools:remove:nuc980 = "trace-enable"
