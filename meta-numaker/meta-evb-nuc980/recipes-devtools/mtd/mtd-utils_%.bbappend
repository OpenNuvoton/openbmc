PACKAGECONFIG:append:nuc980 = " zstd"
PACKAGECONFIG:append:class-native = " zstd"

