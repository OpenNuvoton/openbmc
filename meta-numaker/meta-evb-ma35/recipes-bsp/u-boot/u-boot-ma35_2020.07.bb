DESCRIPTION = "U-Boot for Nuvoton MA35 Series"
require u-boot-ma35.inc
COMPATIBLE_MACHINE = "(ma35d0|ma35d05k)"
