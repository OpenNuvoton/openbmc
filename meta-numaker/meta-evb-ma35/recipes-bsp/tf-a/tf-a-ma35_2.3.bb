SUMMARY = "Trusted Firmware-A for Nuvoton MA35 Series"
require tf-a-ma35.inc
COMPATIBLE_MACHINE = "(ma35d0|ma35d05k)"
