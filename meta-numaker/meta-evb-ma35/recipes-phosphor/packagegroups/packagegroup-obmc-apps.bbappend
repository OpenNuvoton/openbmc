# Remove trace-enable from MA35 series devtools
RDEPENDS:${PN}-devtools:remove:numaker-iot-ma35d0 = "trace-enable"
RDEPENDS:${PN}-devtools:remove:numaker-iot-ma35d05ki1 = "trace-enable"
