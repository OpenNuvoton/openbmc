PACKAGECONFIG:append:ma35 = " zstd"
PACKAGECONFIG:append:class-native = " zstd"

