RDEPENDS:${PN}-devtools:remove:numaker-iot-ma35d05ki1 = "trace-enable"
