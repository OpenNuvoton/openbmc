# MA35D0K5 uses ttyS0 for BMC serial console
SERIAL_CONSOLES = "115200;ttyS0"
